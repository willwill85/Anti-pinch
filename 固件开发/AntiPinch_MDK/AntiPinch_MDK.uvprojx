# Keil uVision project AntiPinch_MDK.uvprojx, settings and files
target APM32E030 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32E030K8 Geehy
  pack: Geehy.APM32E030_DFP.1.0.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AntiPinch_MDK +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: BOARD_APM32E030_TINY,APM32E030x8
  c include: ..\APM32E030_SDK_V1.0.3\Libraries\APM32E030_StdPeriphDriver\inc;..\APM32E030_SDK_V1.0.3\Libraries\CMSIS\Include;..\APM32E030_SDK_V1.0.3\Libraries\Device\Geehy\APM32E030\Include;..\APM32E030_SDK_V1.0.3\Boards;Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    Source/: system_apm32e030.c
    ../APM32E030_SDK_V1.0.3/Libraries/Device/Geehy/APM32E030/Source/arm/: startup_apm32e030.s
  group StdPeriphLib
    ../APM32E030_SDK_V1.0.3/Libraries/APM32E030_StdPeriphDriver/src/: apm32e030_eint.c apm32e030_gpio.c apm32e030_rcm.c apm32e030_usart.c apm32e030_misc.c apm32e030_adc.c apm32e030_tmr.c apm32e030_crc.c apm32e030_dbg.c apm32e030_dma.c apm32e030_fmc.c apm32e030_i2c.c apm32e030_iwdt.c apm32e030_ob.c apm32e030_pmu.c apm32e030_rtc.c apm32e030_spi.c apm32e030_syscfg.c apm32e030_wwdt.c
  group Board
    ../APM32E030_SDK_V1.0.3/Boards/: Board.c
  group Application
    Source/: main.c apm32e030_int.c
  group Document
    ./: README.md
