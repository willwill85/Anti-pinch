# Keil uVision project IWDT_FeedDog_Window.uvprojx, settings and files
target APM32E030 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32E030R8 Geehy
  pack: Geehy.APM32E030_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: IWDT_FeedDog_Window
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: BOARD_APM32E030_TINY,APM32E030x8
  c include: ..\..\..\..\..\..\Libraries\APM32E030_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\Device\Geehy\APM32E030\Include;..\..\..\..\..\..\Boards;..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../Source/: system_apm32e030.c
    ../../../../../../Libraries/Device/Geehy/APM32E030/Source/arm/: startup_apm32e030.s
  group StdPeriphLib
    ../../../../../../Libraries/APM32E030_StdPeriphDriver/src/: apm32e030_eint.c apm32e030_gpio.c apm32e030_rcm.c apm32e030_usart.c apm32e030_misc.c apm32e030_iwdt.c
  group Board
    ../../../../../../Boards/: Board.c
  group Application
    ../../Source/: main.c apm32e030_int.c
  group Document
    ../../: readme.txt
