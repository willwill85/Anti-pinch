# Keil uVision project RTOS_RT-Thread.uvprojx, settings and files
target APM32E030_RT-Thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32E030R8 Geehy
  pack: Geehy.APM32E030_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: APM32E030_RT-Thread
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: APM32E030x8,BOARD_APM32E030_TINY
  c include: ..\..\Include;..\..\..\..\..\..\Boards;..\..\..\..\..\..\Libraries\APM32E030_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\Device\Geehy\APM32E030\Include;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Middlewares\RealThread\rtthread-nano-master\rt-thread\components\finsh;..\..\..\..\..\..\Middlewares\RealThread\rtthread-nano-master\rt-thread\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/APM32E030/Source/arm/: startup_apm32e030.s
    ../../Source/: system_apm32e030.c
  group StdPeriphDriver
    ../../../../../../Libraries/APM32E030_StdPeriphDriver/src/: apm32e030_adc.c apm32e030_crc.c apm32e030_dbg.c apm32e030_dma.c apm32e030_eint.c apm32e030_fmc.c apm32e030_gpio.c apm32e030_i2c.c apm32e030_iwdt.c apm32e030_misc.c apm32e030_ob.c apm32e030_pmu.c apm32e030_rcm.c apm32e030_rtc.c apm32e030_spi.c apm32e030_syscfg.c apm32e030_tmr.c apm32e030_usart.c apm32e030_wwdt.c
  group Application
    ../../Source/: apm32e030_int.c main.c
  group Board
    ../../../../../../Boards/: Board.c
  group RT-Thread
    ../../../../../../Middlewares/RealThread/rtthread-nano-master/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../Source/: rtthread_board.c
    ../../../../../../Middlewares/RealThread/rtthread-nano-master/rt-thread/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group Finsh
    ../../../../../../Middlewares/RealThread/rtthread-nano-master/rt-thread/components/finsh/: cmd.c msh.c shell.c
    ../../Source/: finsh_port.c
  group Document
    ../../: readme.txt
