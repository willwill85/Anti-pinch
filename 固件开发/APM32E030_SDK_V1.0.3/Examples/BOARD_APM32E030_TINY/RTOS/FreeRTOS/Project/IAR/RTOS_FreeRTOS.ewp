# IAR project RTOS_FreeRTOS.ewp, settings and files
configuration APM32E030 (ARM, debug)
  General.OGChipSelectEditMenu: APM32E030x8 Geehy APM32E030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_APM32E030_TINY; APM32E030
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\APM32E030_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32E030\Include; ..\..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Include
  OBJCOPY.OOCOutputFile: RTOS_FreeRTOS.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: readme.txt
  group Application
    ../../Source/: apm32e030_int.c main.c
  group Boards
    ../../../../../../Boards/: Board.c
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/APM32E030/Source/iar/: startup_apm32e030.s
    ../../Source/: system_apm32e030.c
  group FREE_RTOS
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group StdPeriphDriver
    ../../../../../../Libraries/APM32E030_StdPeriphDriver/src/: apm32e030_adc.c apm32e030_crc.c apm32e030_dbg.c apm32e030_dma.c apm32e030_eint.c apm32e030_fmc.c apm32e030_gpio.c apm32e030_i2c.c apm32e030_iwdt.c apm32e030_misc.c apm32e030_ob.c apm32e030_pmu.c apm32e030_rcm.c apm32e030_rtc.c apm32e030_spi.c apm32e030_syscfg.c apm32e030_tmr.c apm32e030_usart.c apm32e030_wwdt.c
