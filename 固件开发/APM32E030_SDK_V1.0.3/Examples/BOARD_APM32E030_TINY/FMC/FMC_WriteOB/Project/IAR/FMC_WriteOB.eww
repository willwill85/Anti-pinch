<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FMC_WriteOB.ewp</path>
    </project>
    <batchBuild />
</workspace>
