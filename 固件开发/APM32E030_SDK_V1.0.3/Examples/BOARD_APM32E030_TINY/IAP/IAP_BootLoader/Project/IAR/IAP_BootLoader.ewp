# IAR project IAP_BootLoader.ewp, settings and files
configuration APM32E030 (ARM, debug)
  General.OGChipSelectEditMenu: APM32E030x8 Geehy APM32E030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_APM32E030_TINY; APM32E030x8
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Libraries\APM32E030_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32E030\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: IAP_BootLoader.out
  ILINK.IlinkIcfFile: IAP_BootLoader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32e030_int.c common.c main.c menu.c ymodem.c
  group Board
    ../../../../../../Boards/: Board.c
  group Bsp
    ../../Source/: bsp_flash.c bsp_usart.c
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/APM32E030/Source/iar/: startup_apm32e030.s
    ../../Source/: system_apm32e030.c
  group Document
    ../../: readme.txt
  group StdPeriphDriver
    ../../../../../../Libraries/APM32E030_StdPeriphDriver/src/: apm32e030_adc.c apm32e030_crc.c apm32e030_dma.c apm32e030_eint.c apm32e030_fmc.c apm32e030_gpio.c apm32e030_i2c.c apm32e030_iwdt.c apm32e030_misc.c apm32e030_pmu.c apm32e030_rcm.c apm32e030_rtc.c apm32e030_spi.c apm32e030_tmr.c apm32e030_usart.c apm32e030_wwdt.c
